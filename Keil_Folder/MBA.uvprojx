# Keil uVision project MBA.uvprojx, settings and files
target MBAUSB (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MuBA +hex
  c flags: Optim=3 oTime=1 wLevel=2
  c define: HSE_VALUE=25000000
  c include: .;..\MuBA\SourceCode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APPLAYER
    ../SourceCode/APPLAYER/: OSSupport.c OSSupport.h
    ../SourceCode/APPLAYER/DeviceInterface/: DeviceApp.c DeviceApp.h
    ../SourceCode/APPLAYER/Communication/: BUSApp.c MBAApp.c BUSApp.h MBAApp.h
    ../SourceCode/: main.c
  group MBALIBRARY
    ../SourceCode/MBALibrary/: MBALib.h MBATypes.h
    ../SourceCode/MBALibrary/MBADictionary/: MBADictionary.h MBADictionary.c
    ../SourceCode/MBALibrary/MBAProtocols/: MBAConfigProtocol.h MBAOperationProtocol.h MBATransferProtocol.h MBAConfigProtocol.c MBAOperationProtocol.c MBATransferProtocol.c
    ../SourceCode/MBALibrary/MBAProtocols/MBAOperationProtocolStates/: ActiveState.h ConfigState.h DisconnectedState.h FaultDetectedState.h FaultState.h InactiveState.h InitState.h ScanState.h ActiveState.c ConfigState.c DisconnectedState.c FaultDetectedState.c FaultState.c InactiveState.c InitState.c ScanState.c
  group PHDLLAYER
    ../SourceCode/PHDLLAYER/IRQHANDLE/: Interrupt_Functions.c Interrupt_Functions.h
    ../SourceCode/PHDLLAYER/BOARDAPI/: boardAPI.c boardAPI.h
    ../SourceCode/PHDLLAYER/BUSAPI/: BUSAPI.c BUSAPI.h
    ../SourceCode/PHDLLAYER/BUSAPI/USBAPI/: USBAPI.c USBD_User_CustomClass_0.c USBD_User_CustomClass_1.c USBAPI.h
    ../SourceCode/PHDLLAYER/BUSAPI/SPIAPI/: SPIAPI.c SPIAPI.h
    ../SourceCode/PHDLLAYER/BUSAPI/USARTAPI/: USARTAPI.c USARTAPI.h
  group TOOLS
    ../SourceCode/TOOLS/: BufferFunctions.h MemoryManagement.h BufferFunctions.c MemoryManagement.c
  group SYSTEMFILES
    ./: SysConfig.h
target SYSTEMTEST (ARM-GNU)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: as above
  output: MBA
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, CMSIS:RTOS:Keil RTX 4.78.0, USB:CORE 6.3.0, USB:Device 6.3.0, USB:Device:Custom Class 6.3.0, CMSIS Driver:SPI 2.02, CMSIS Driver:USART 2.01, CMSIS Driver:USB Device:Full-speed 2.06, CMSIS Driver:USB Device:High-speed 2.06, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:ADC 1.1.0, Device:STM32Cube HAL:CAN 1.1.0, Device:STM32Cube HAL:CRC 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DAC 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:HCD 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:I2S 1.1.0, Device:STM32Cube HAL:IRDA 1.1.0, Device:STM32Cube HAL:IWDG 1.1.0, Device:STM32Cube HAL:NAND 1.1.0, Device:STM32Cube HAL:NOR 1.1.0, Device:STM32Cube HAL:PC Card 1.1.0, Device:STM32Cube HAL:PCD 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RNG 1.1.0, Device:STM32Cube HAL:RTC 1.1.0, Device:STM32Cube HAL:SD 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:SRAM 1.1.0, Device:STM32Cube HAL:Smartcard 1.1.0, Device:STM32Cube HAL:TIM 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:STM32Cube HAL:WWDG 1.1.0, Device:Startup 2.1.0
